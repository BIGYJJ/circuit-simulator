.control
run
.endc
